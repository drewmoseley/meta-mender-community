PROVIDES += "kernel"