FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_imx8mnevk = " file://02_console_grub.cfg;subdir=git"
SRC_URI_append_imx8mqevk = " file://02_console_grub.cfg;subdir=git"
SRC_URI_append_imx8mmevk = " file://02_console_grub.cfg;subdir=git"
